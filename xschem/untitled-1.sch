v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {OFC.sym} -180 -10 0 0 {name=x1}
